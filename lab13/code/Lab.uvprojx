# Keil uVision project Lab.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CT_Board_HS14_M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Lab_3
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: action_handler.c event_handler.c main.c state_machine.c timer.c
  group unittest
    ./unittest/: main.c arm_peripherals.c arm_peripherals.h test_action_handler.c test_event_handler.c test_state_machine.c
software components: Device:Startup 3.0.5, HAL:CT Board:LCD 3.0.3, HAL:FMC 3.0.1, HAL:GPIO 3.0.3, HAL:PWR 2.2.0, HAL:RCC 3.0.1, HAL:TIMER 4.0.0
